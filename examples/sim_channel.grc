options:
  parameters:
    author: kmcomer
    generate_options: qt_gui
    id: sim_channel
    output_language: python
    title: Turbo Codec simple example
  states: {}

blocks:
- name: constellation
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: dec_turbo
  id: variable_turbo_decoder_def
  parameters:
    dim1: '1'
    dim2: '1'
    framebits: frame_size*8
    ndim: '0'
    value: '"ok"'
  states: {}
- name: dec_turbo_0
  id: variable_turbo_decoder_def
  parameters:
    dim1: '1'
    dim2: '1'
    framebits: frame_size*8
    ndim: '0'
    value: '"ok"'
  states: {state: disabled}
- name: enc_turbo
  id: variable_turbo_encoder_def
  parameters:
    buffered: 'True'
    dim1: '1'
    dim2: '1'
    framebits: frame_size*8
    ndim: '0'
    polys: '[0o13, 0o15]'
    standard: fec_dev.LTE
    subencoder: fec_dev.RSC
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: sigma
  id: variable_qtgui_range
  parameters:
    start: '0.001'
    step: '0.001'
    stop: '1'
    value: '0.001'
    widget: eng_slider
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: sigma
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_2
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_3
  id: blocks_char_to_float
  parameters:
    scale: 2 / sigma**2
  states: {state: disabled}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: complex
  states: {state: disabled}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_vector_sink_x_0
  id: blocks_vector_sink_x
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: 2*(frame_size//15)*[0, 0, 1, 0, 3, 0, 7, 0, 15, 0, 31, 0, 63, 0, 127]
  states: {}
- name: dec_turbo
  id: fec_dev_turbo_decoder
  parameters:
    dim1: '1'
    dim2: '1'
    framebits: '20'
    ndim: '0'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: constellation
  states: {state: disabled}
- name: digital_constellation_encoder_bc_0
  id: digital_constellation_encoder_bc
  parameters:
    constellation: constellation
  states: {}
- name: enc_turbo
  id: fec_dev_turbo_encoder
  parameters:
    dim1: '1'
    dim2: '1'
    framebits: '2048'
    ndim: '0'
    t: '180'
  states: {}
- name: fec_generic_decoder_0
  id: fec_generic_decoder
  parameters:
    decoder: dec_turbo
    itype: float
    otype: byte
  states: {}
- name: fec_generic_encoder_0
  id: fec_generic_encoder
  parameters:
    encoder: enc_turbo
    itype: byte
    otype: byte
  states: {}
- name: frame_size
  id: parameter
  parameters:
    label: Frame Size
    type: intx
    value: '48'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    label1: Input
    label2: Decoded
    nconnections: '2'
    size: frame_size*2
    srate: samp_rate
    type: float
    ymin: '0'
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '0']
- [blocks_add_xx_0, '0', fec_generic_decoder_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_char_to_float_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_char_to_float_2, '0', qtgui_time_sink_x_0, '1']
- [blocks_char_to_float_3, '0', blocks_add_xx_0, '1']
- [blocks_complex_to_real_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_0, '0', fec_generic_decoder_0, '0']
- [blocks_throttle2_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_char_to_float_1, '0']
- [blocks_unpack_k_bits_bb_0, '0', fec_generic_encoder_0, '0']
- [blocks_vector_source_x_0, '0', blocks_throttle2_0, '0']
- [digital_constellation_encoder_bc_0, '0', blocks_complex_to_real_0, '0']
- [fec_generic_decoder_0, '0', blocks_char_to_float_0, '0']
- [fec_generic_decoder_0, '0', blocks_vector_sink_x_0, '0']
- [fec_generic_encoder_0, '0', blocks_char_to_float_2, '0']
- [fec_generic_encoder_0, '0', blocks_char_to_float_3, '0']
- [fec_generic_encoder_0, '0', digital_constellation_decoder_cb_0, '0']
- [fec_generic_encoder_0, '0', digital_constellation_encoder_bc_0, '0']

metadata:
  file_format: 1
  grc_version: gac2244fa1
